Commit message: orin nano上的独有更新

File: src/rm_gimbal_description/urdf/rm_gimbal.urdf.xacro (robot description, xacro)
@@ -17,5 +17,5 @@
     <parent link="yaw_link" />
     <child link="pitch_link" />
-    <axis xyz="0 1 0" />
+    <axis xyz="0 -1 0" />
   </joint>
   <link name="camera_link" />
